# IAR project strong-arm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.IExtraOptions: --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\src\private; ..\libraries\CMSIS\ST\STM32F4xx\Include; ..\libraries\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: strong-arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../inc/: ecdsa.h finite_field.h random.h ripemd160.h
  group ECDSA
    ../src/ecdsa/: ecdsa.c
  group finite_field
    ../src/finite_field/: ff_big.c ff_big.h finite_field.c
  group private
    ../src/private/: util.c util.h
  group random
    ../src/random/: random.c
  group RIPEMD160
    ../src/ripemd160/: ripemd160.c
