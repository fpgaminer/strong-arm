# IAR project strong-arm-test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.IExtraOptions: --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ..\libraries\CMSIS\ST\STM32F4xx\Include; ..\libraries\CMSIS\Include; ..\inc; ..\tests
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: strong-arm-test.srec
  ILINK.IlinkOutputFile: strong-arm-test.out
  ILINK.IlinkAdditionalLibs: Debug\Exe\strong-arm.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../tests/: ecdsa.c finite_field.c main.c minunit.h ripemd160.c system_stm32f4xx.c
    ../libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
